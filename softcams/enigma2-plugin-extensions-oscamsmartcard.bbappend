SRC_URI="git://github.com/TwolDe2/oscamsmartcard.git"
